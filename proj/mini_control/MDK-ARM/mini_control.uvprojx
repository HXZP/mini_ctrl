# Keil uVision project mini_control.uvprojx, settings and files
target mini_control (6230000::V6.23::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: mini_control +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FatFs/src/drivers;../../../user/Application/Sys;../../../user/Application/App;../../../user/Application/Drv;../../../user/hxzp_device;../../../user/hxzp_Lib;../../../user/Unit;../../../user/Unit/cm_backtrace;../../../user/hxzp_device/bmi270;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c sdio.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_sd.c stm32f1xx_hal_mmc.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Application/Sys
    ../../../user/Application/Sys/: board_config.h system.c
  group Application/App
    ../../../user/Application/App/: Test.c user_init.c user_key.c
  group Application/Drv
    ../../../user/Application/Drv/: drv_init.c drv_key.c drv_lcd.c drv_led.c drv_usart.c drv_usb.c drv_bmi270.c
  group Application/USB
    ../../../user/Application/App_USB/App/: usbd_cdc_if.c usbd_storage_if.c usb_device.c usbd_desc.c
    ../../../user/Application/App_USB/Target/: usbd_conf.c
  group Lib
    ../../../user/hxzp_Lib/: hxzp_key.c hxzp_led.c hxzp_list.c hxzp_ringbuff.c hxzp_template.c hxzp_lib.h
  group Device
    ../../../user/hxzp_device/: hxzp_st7789.c
  group Device/bmi270
    ../../../user/hxzp_device/bmi270/: bmi2.c bmi270.c
  group Unit/cmbacktrace
    ../../../user/Unit/cm_backtrace/: cm_backtrace.c cmb_cfg.h cmb_def.h
    ../../../user/Unit/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group Unit/USB/CORE
    ../../../user/Unit/usb/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Unit/USB/CDC
    ../../../user/Unit/usb/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Unit/USB/MSC
    ../../../user/Unit/usb/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Unit/WouoUI
    ../../../user/Unit/WouoUI/: WouoUI.c WouoUI_font.c WouoUI_oled.c WouoUI_page.c WouoUI_port.c WouoUI_user.c WouoUI_widget.c WouoUI_win.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
software components: CMSIS:CORE 5.6.0, Compiler:Event Recorder 1.5.1
